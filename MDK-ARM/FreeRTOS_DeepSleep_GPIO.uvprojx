# Keil uVision project FreeRTOS_DeepSleep_GPIO.uvprojx, settings and files
target Example (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_Tester +hex
  AfterMake: .\HexView\hexview.exe .\Objects\FM33LC0xx_Tester.hex /CR:0x20007FFC,0x20007FFF -o .\Objects\FM33LC0xx_Tester.hex
  AfterMake: .\srec_cat.exe .\Objects\FM33LC0xx_Tester.hex -Intel ..\..\S51EV_Passenger_SeatControl_FBL\MDK-ARM\Objects\FM33XX_bootload.hex -Intel -o SH52EV_boot_app.hex -Intel
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\FM33LG0xx_FL_Driver\Inc;..\MF-config\Inc;..\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\Tickless;..\Inc\Cdd;..\Inc\Driverif;..\Inc\App;..\Inc\Service;..\Inc\CanStack;..\Inc\Calibration;..\Inc\CanNm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7ffb
  scatter file: .\FM33LC0xx_Tester.sct
  link misc: --pad=0xFF
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c user_init.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_wwdt.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_vrefp.c fm33lg0xx_fl_exti.c
  group FreeRTOS_Code
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group FreeRTOS_Tickless
    ../Tickless/: Tickless_Hook.c
  group Driverif
    ../Src/Driverif/: Adcif.c Canif.c Compif.c GpioCfg.c Ioif.c EepromIf.c Iwdt.c
  group Cdd
    ../Src/Cdd/: CddKey.c CddTest.c CddEeprom.c CddEeprom_Cfg.c CddMtr_Ctrl.c CddMtr_HFKF.c CddMtr_Mng.c lookup.c CddModeM.c CddModeM_Cfg.c
  group App
    ../Src/App/: PowerMgmt.c Scm_SeatControl.c CanNm_UserData.c
  group CanStack
    ../Src/CanStack/: diag_kwp2k_di_core_erlg.c diag_kwp2k_di_core_mgr.c diag_kwp2k_di_core_nvm.c fdiag.c il.c il_par.c kwpdiag.c nw_can_dll.c tcan_test.c tp.c tp_par.c vnim_app_signals.c vnim_busoff_hndlr.c vnim_di_nos.c vnim_diag.c rx_can.c
  group Calibration
    ../Src/Calibration/: CddMtr_Cal.c
  group System
    ../Src/System/: System_OsApp.c System_OsMessageQueue.c System_OsTask.c System_OsTaskCfg.c
  group CanNm
    ../Src/CanNM/: CanNm.c CanNmCtrl.c
